# Keil uVision project gateway.uvprojx, settings and files
target gateway (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: gateway +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Com;../Mid/FreeRTOS/include;../Mid/FreeRTOS/portable/RVDS;../App;../Int/ETHERNET;../Int/ETHERNET/W5500;../Int/MQTT;../Int/MQTT/MQTTPacket/src;../Int/MODBUS;../Int/CAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Com
    ../Com/: Com_Debug.c Com_Delay.c cJSON.c
  group mid/freeRTOS
    ../Mid/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Mid/FreeRTOS/portable/MemMang/: heap_4.c
    ../Mid/FreeRTOS/portable/RVDS/: port.c
  group App
    ../App/: App_Main.c App_Task1.c
  group Int/w5500
    ../Int/ETHERNET/: Int_W5500.c socket.c wizchip_conf.c
    ../Int/ETHERNET/W5500/: w5500.c
  group Int/mqtt
    ../Int/MQTT/: mqtt_interface.c MQTTClient.c Int_MQTT_Client.c
    ../Int/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group int/modbus
    ../Int/MODBUS/: Int_Modbus.c mbcrc.c
  group int/can
    ../Int/CAN/: Int_CAN.c
software components: CMSIS:CORE 4.3.0
